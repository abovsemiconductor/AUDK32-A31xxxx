# Keil uVision project tmpl_userapp.uvprojx, settings and files
target A31G11x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: tmpl_userapp
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G11x EXTRN_ABOV_MODULE_CONFIG
  c include: ..\..\..\..\Framework\CMSIS\Core\Include;..\..\..\..\Framework\CMSIS\Device\ABOV\Include;..\..\..\..\ProductConfig\Config;..\..\..\..\Platform\HAL\Include;..\..\..\..\Platform\HAL\HPL\Include;..\..\..\..\Platform\Library\ABOV\Debug\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31g11x.sct
  link misc: --diag_suppress L6314W --diag_suppress L6329W
  group Config
    ../../../../ProductConfig/Config/: abov_config.h abov_module_config.h
  group Main
    ../../../Source/TmplUserApp/: main.c prv_scu_clk.c prv_user_code.c
  group Startup
    ../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a31xxxx.c
  group System
    ../../../../Framework/CMSIS/Device/ABOV/Source/: system_a31xxxx.c
  group HAL
    ../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c hal_scu_lvd.c hal_scu_pwr.c
    ../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../Platform/HAL/ADC/: hal_adc.c
    ../../../../Platform/HAL/DAC/: hal_dac.c
    ../../../../Platform/HAL/CMP/: hal_cmp.c
    ../../../../Platform/HAL/CRC/: hal_crc.c
    ../../../../Platform/HAL/TempSens/: hal_tempsens.c
    ../../../../Platform/HAL/EBI/: hal_ebi.c
    ../../../../Platform/HAL/CFMC/: hal_cfmc.c
    ../../../../Platform/HAL/FMC/: hal_fmc.c
    ../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
    ../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../Platform/HAL/LCD/: hal_lcd.c
    ../../../../Platform/HAL/LED/: hal_led.c
    ../../../../Platform/HAL/Timer1/: hal_timer1.c
    ../../../../Platform/HAL/Timer2/: hal_timer2.c
    ../../../../Platform/HAL/Timer3/: hal_timer3.c
    ../../../../Platform/HAL/Timer4/: hal_timer4.c
    ../../../../Platform/HAL/Timer4E/: hal_timer4e.c
    ../../../../Platform/HAL/Timer5/: hal_timer5.c
    ../../../../Platform/HAL/Timer6/: hal_timer6.c
    ../../../../Platform/HAL/WDT/: hal_wdt.c
    ../../../../Platform/HAL/WT/: hal_wt.c
    ../../../../Platform/HAL/RTC/: hal_rtc.c
    ../../../../Platform/HAL/FRT/: hal_frt.c
    ../../../../Platform/HAL/I2C/: hal_i2c.c
    ../../../../Platform/HAL/SPI/: hal_spi.c
    ../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../Platform/HAL/LPUART/: hal_lpuart.c
    ../../../../Platform/HAL/USART/: hal_usart.c
    ../../../../Platform/HAL/TRNG/: hal_trng.c
    ../../../../Platform/HAL/AES/: hal_aes.c
  group PrivateHAL
    ../../../../Platform/HAL/CFMC/Fx/F1x/: hal_cfmc_f_01_00_00.c hal_cfmc_f_01_00_01.c
  group Debug
    ../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
target A31G12x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: tmpl_userapp
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G12x EXTRN_ABOV_MODULE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31g12x.sct
  link misc: --diag_suppress L6314W --diag_suppress L6329W
target A31G21x (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: tmpl_userapp
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G21x EXTRN_ABOV_MODULE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31g21x.sct
  link misc: --diag_suppress L6314W --diag_suppress L6329W
target A31T21x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: tmpl_userapp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31T21x  EXTRN_ABOV_MODULE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31xxxx.sct
  link misc: --diag_suppress L6314W --diag_suppress L6329W
target A31G22x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: tmpl_userapp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G22x EXTRN_ABOV_MODULE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: as above
  link misc: --diag_suppress L6314W --diag_suppress L6329W
target A31G31x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: tmpl_userapp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G31x EXTRN_ABOV_MODULE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: as above
  link misc: --diag_suppress L6314W --diag_suppress L6329W
target A31G32x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: tmpl_userapp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G32x EXTRN_ABOV_MODULE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: as above
  link misc: --diag_suppress L6314W --diag_suppress L6329W
target A31L21x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: tmpl_userapp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31L21x EXTRN_ABOV_MODULE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31l21x.sct
  link misc: --diag_suppress L6314W --diag_suppress L6329W
target A31L12x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: tmpl_userapp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31L12x EXTRN_ABOV_MODULE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31l12x.sct
  link misc: --diag_suppress L6314W --diag_suppress L6329W
target A31L22x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: tmpl_userapp
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31L22x EXTRN_ABOV_MODULE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31l22x.sct
  link misc: --diag_suppress L6314W --diag_suppress L6329W
target A31C14x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: tmpl_userapp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31C14x EXTRN_ABOV_MODULE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31c14x.sct
  link misc: --diag_suppress L6314W --diag_suppress L6329W
target A31G33x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: tmpl_userapp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G33x EXTRN_ABOV_MODULE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31g33x.sct
  link misc: --diag_suppress L6314W --diag_suppress L6329W
target A31G34x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: tmpl_userapp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G34x EXTRN_ABOV_MODULE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31g34x.sct
  link misc: --diag_suppress L6314W --diag_suppress L6329W
target A31S13x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: tmpl_userapp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31S13x EXTRN_ABOV_MODULE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31s13x.sct
  link misc: --diag_suppress L6314W --diag_suppress L6329W
