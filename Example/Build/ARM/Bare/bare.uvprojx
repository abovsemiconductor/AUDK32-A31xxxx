# Keil uVision project bare.uvprojx, settings and files
target A31G11x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: bare
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G11x EXTRN_ABOV_EXAMPLE_CONFIG EXTRN_SINGLE_ADC
  c include: ..\..\..\..\Framework\CMSIS\Core\Include;..\..\..\..\Framework\CMSIS\Device\ABOV\Include;..\..\..\..\ProductConfig\Config;..\..\..\..\Platform\HAL\Include;..\..\..\..\Platform\HAL\HPL\Include;..\..\..\..\Platform\Library\ABOV\Debug\Include;..\..\..\..\Example\Source\Bare\Peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31g11x.sct
  link misc: --diag_suppress L6314W
  group Config
    ../../../../ProductConfig/Config/: abov_config.h abov_example_config.h
  group Main
    ../../../Source/Bare/Peripheral/Main/: ex_peripheral.c ex_common.c
  group Example
    ../../../Source/Bare/Peripheral/SCU/: scu.c scu_clk.c scu_pwr.c scu_lvd.c
    ../../../Source/Bare/Peripheral/PCU/: pcu.c
    ../../../Source/Bare/Peripheral/Timer1/: timer1.c
    ../../../Source/Bare/Peripheral/Timer2/: timer2.c
    ../../../Source/Bare/Peripheral/Timer3/: timer3.c
    ../../../Source/Bare/Peripheral/Timer4/: timer4.c
    ../../../Source/Bare/Peripheral/Timer4E/: timer4e.c
    ../../../Source/Bare/Peripheral/Timer5/: timer5.c
    ../../../Source/Bare/Peripheral/Timer6/: timer6.c
    ../../../Source/Bare/Peripheral/WDT/: wdt.c
    ../../../Source/Bare/Peripheral/WT/: wt.c
    ../../../Source/Bare/Peripheral/I2C/: i2c.c
    ../../../Source/Bare/Peripheral/SPI/: spi.c
    ../../../Source/Bare/Peripheral/UART/: uart.c
    ../../../Source/Bare/Peripheral/USART/: usart.c
    ../../../Source/Bare/Peripheral/ADC/: adc.c
    ../../../Source/Bare/Peripheral/DAC/: dac.c
    ../../../Source/Bare/Peripheral/CMP/: cmp.c
    ../../../Source/Bare/Peripheral/CRC/: crc.c
    ../../../Source/Bare/Peripheral/Flash/: code_flash.c flash.c
    ../../../Source/Bare/Peripheral/LCD/: lcd.c
    ../../../Source/Bare/Peripheral/LED/: led.c
    ../../../Source/Bare/Peripheral/EBI/: ebi.c
    ../../../Source/Bare/Peripheral/RTC/: rtc.c
    ../../../Source/Bare/Peripheral/TempSens/: tempsens.c
    ../../../Source/Bare/Peripheral/COA/: coa.c
    ../../../Source/Bare/Peripheral/LPUART/: lpuart.c
    ../../../Source/Bare/Peripheral/AES/: aes.c
    ../../../Source/Bare/Peripheral/TRNG/: trng.c
    ../../../Source/Bare/Peripheral/FRT/: frt.c
  group Startup
    ../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a31xxxx.c
  group System
    ../../../../Framework/CMSIS/Device/ABOV/Source/: system_a31xxxx.c
  group HAL
    ../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c hal_scu_lvd.c hal_scu_pwr.c
    ../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
    ../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../Platform/HAL/USART/: hal_usart.c
    ../../../../Platform/HAL/Timer1/: hal_timer1.c
    ../../../../Platform/HAL/Timer2/: hal_timer2.c
    ../../../../Platform/HAL/Timer3/: hal_timer3.c
    ../../../../Platform/HAL/Timer4/: hal_timer4.c
    ../../../../Platform/HAL/WDT/: hal_wdt.c
    ../../../../Platform/HAL/WT/: hal_wt.c
    ../../../../Platform/HAL/CRC/: hal_crc.c
    ../../../../Platform/HAL/CMP/: hal_cmp.c
    ../../../../Platform/HAL/I2C/: hal_i2c.c
    ../../../../Platform/HAL/SPI/: hal_spi.c
    ../../../../Platform/HAL/CFMC/: hal_cfmc.c
    ../../../../Platform/HAL/FMC/: hal_fmc.c
    ../../../../Platform/HAL/DAC/: hal_dac.c
    ../../../../Platform/HAL/ADC/: hal_adc.c
    ../../../../Platform/HAL/LCD/: hal_lcd.c
    ../../../../Platform/HAL/LED/: hal_led.c
    ../../../../Platform/HAL/RTC/: hal_rtc.c
    ../../../../Platform/HAL/EBI/: hal_ebi.c
    ../../../../Platform/HAL/TempSens/: hal_tempsens.c
    ../../../../Platform/HAL/Timer4E/: hal_timer4e.c
    ../../../../Platform/HAL/Timer5/: hal_timer5.c
    ../../../../Platform/HAL/Timer6/: hal_timer6.c
    ../../../../Platform/HAL/LPUART/: hal_lpuart.c
    ../../../../Platform/HAL/AES/: hal_aes.c
    ../../../../Platform/HAL/TRNG/: hal_trng.c
    ../../../../Platform/HAL/FRT/: hal_frt.c
  group PrivateHAL
    ../../../../Platform/HAL/CFMC/Fx/F1x/: hal_cfmc_f_01_00_00.c hal_cfmc_f_01_00_01.c
  group Debug
    ../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group Linker_AC5
    ../../../../Framework/CMSIS/Device/ABOV/Source/ARM/: ac5_a31xxxx.sct ac5_a31g21x.sct ac5_a31g12x.sct ac5_a31g11x.sct ac5_a31l21x.sct ac5_a31l12x.sct ac5_a31l22x.sct ac5_a31c14x.sct ac5_a31c12x.sct
  group Linker_AC6
    ../../../../Framework/CMSIS/Device/ABOV/Source/ARM/: ac6_a31xxxx.sct ac6_a31g21x.sct ac6_a31g12x.sct ac6_a31g11x.sct ac6_a31l21x.sct ac6_a31l12x.sct ac6_a31l22x.sct ac6_a31c14x.sct ac6_a31c12x.sct
target A31G12x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G12x EXTRN_ABOV_EXAMPLE_CONFIG EXTRN_SINGLE_ADC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31g12x.sct
  link misc: --diag_suppress L6314W
target A31G21x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G21x EXTRN_ABOV_EXAMPLE_CONFIG EXTRN_SINGLE_ADC EXTRN_EX_LED_DEBUG_OTHER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31g21x.sct
  link misc: --diag_suppress L6314W
target A31T21x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31T21x EXTRN_ABOV_EXAMPLE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31xxxx.sct
  link misc: --diag_suppress L6314W
target A31G22x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G22x EXTRN_ABOV_EXAMPLE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: as above
  link misc: --diag_suppress L6314W
target A31G31x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G31x EXTRN_ABOV_EXAMPLE_CONFIG EXTRN_EX_LED_DEBUG_OTHER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: as above
  link misc: --diag_suppress L6314W
target A31G32x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G32x EXTRN_ABOV_EXAMPLE_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: as above
  link misc: --diag_suppress L6314W
target A31L21x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31L21x EXTRN_ABOV_EXAMPLE_CONFIG EXTRN_SINGLE_ADC EXTRN_EX_LED_DEBUG_OTHER EXTRN_HAS_DEEP_SLEEP_SUB_MODE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31l21x.sct
  link misc: --diag_suppress L6314W
target A31L12x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31L12x EXTRN_ABOV_EXAMPLE_CONFIG EXTRN_SINGLE_ADC EXTRN_EX_LED_DEBUG_OTHER EXTRN_HAS_DEEP_SLEEP_SUB_MODE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31l12x.sct
  link misc: --diag_suppress L6314W
target A31L22x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31L22x EXTRN_ABOV_EXAMPLE_CONFIG EXTRN_SINGLE_ADC EXTRN_EX_LED_DEBUG_OTHER EXTRN_HAS_DEEP_SLEEP_SUB_MODE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31l22x.sct
  link misc: --diag_suppress L6314W
target A31S13x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31S13x EXTRN_ABOV_EXAMPLE_CONFIG EXTRN_SINGLE_ADC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31s13x.sct
  link misc: --diag_suppress L6314W
target A31G33x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G33x EXTRN_ABOV_EXAMPLE_CONFIG EXTRN_SINGLE_ADC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31g33x.sct
  link misc: --diag_suppress L6314W
target A31G34x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bare
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31G34x EXTRN_ABOV_EXAMPLE_CONFIG EXTRN_SINGLE_ADC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31g34x.sct
  link misc: --diag_suppress L6314W
