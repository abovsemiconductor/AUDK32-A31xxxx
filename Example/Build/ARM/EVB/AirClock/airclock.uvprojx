# Keil uVision project airclock.uvprojx, settings and files
target A31C14x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: airclock
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EXTRN_SUBFAMILY_A31C14x EXTRN_VARIANT_A31C144RLN_ADK CONFIG_HAL_USART CONFIG_HAL_UART CONFIG_HAL_I2C CONFIG_HAL_TIMER1 EX_SSD1309=1 CONFIG_HAL_FRT CONFIG_HAL_ADC
  c include: ..\..\..\..\..\Framework\CMSIS\Core\Include;..\..\..\..\..\Framework\CMSIS\Device\ABOV\Include;..\..\..\..\..\ProductConfig\Config;..\..\..\..\..\Platform\HAL\Include;..\..\..\..\..\Platform\HAL\HPL\Include;..\..\..\..\..\Platform\Library\ABOV\Debug\Include;..\..\..\..\..\Example\Source\AirClock\Include;..\..\..\..\..\Platform\Library\U8g2\csrc;..\..\..\..\..\Platform\OS\FreeRTOS\include;..\..\..\..\..\Platform\OS\FreeRTOS\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac5_a31c14x.sct
  link misc: --diag_suppress L6314W
  group Main
    ../../../../Source/AirClock/: airclock.c u8g2hwinf.c airclock_sensor.c eeprom_24lc512.c leddrv_al8700.c snor_w25q16jv.c ir_receiver.c adc_rs3011.c button.c buzzer_bmx2705.c gpio_shared_irq.c hw_timer.c menu.c oled.c user_queue.c softtimer.c u8g2_graphic.c airclock_fr.c app_event_fr.c button_fr.c gpio_shared_irq_fr.c ir_receiver_fr.c
  group Startup
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a31xxxx.c
  group System
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: system_a31xxxx.c
  group HAL
    ../../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c hal_scu_lvd.c hal_scu_pwr.c
    ../../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
    ../../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../../Platform/HAL/USART/: hal_usart.c
    ../../../../../Platform/HAL/LPUART/: hal_lpuart.c
    ../../../../../Platform/HAL/Timer1/: hal_timer1.c
    ../../../../../Platform/HAL/Timer2/: hal_timer2.c
    ../../../../../Platform/HAL/Timer3/: hal_timer3.c
    ../../../../../Platform/HAL/Timer4/: hal_timer4.c
    ../../../../../Platform/HAL/Timer4E/: hal_timer4e.c
    ../../../../../Platform/HAL/Timer5/: hal_timer5.c
    ../../../../../Platform/HAL/Timer6/: hal_timer6.c
    ../../../../../Platform/HAL/WDT/: hal_wdt.c
    ../../../../../Platform/HAL/WT/: hal_wt.c
    ../../../../../Platform/HAL/RTC/: hal_rtc.c
    ../../../../../Platform/HAL/FRT/: hal_frt.c
    ../../../../../Platform/HAL/CRC/: hal_crc.c
    ../../../../../Platform/HAL/CMP/: hal_cmp.c
    ../../../../../Platform/HAL/I2C/: hal_i2c.c
    ../../../../../Platform/HAL/SPI/: hal_spi.c
    ../../../../../Platform/HAL/CFMC/: hal_cfmc.c
    ../../../../../Platform/HAL/FMC/: hal_fmc.c
    ../../../../../Platform/HAL/DAC/: hal_dac.c
    ../../../../../Platform/HAL/ADC/: hal_adc.c
    ../../../../../Platform/HAL/LCD/: hal_lcd.c
    ../../../../../Platform/HAL/LED/: hal_led.c
    ../../../../../Platform/HAL/EBI/: hal_ebi.c
    ../../../../../Platform/HAL/TempSens/: hal_tempsens.c
    ../../../../../Platform/HAL/AES/: hal_aes.c
    ../../../../../Platform/HAL/TRNG/: hal_trng.c
  group PrivateHAL
    ../../../../../Platform/HAL/CFMC/Fx/F1x/: hal_cfmc_f_01_00_00.c hal_cfmc_f_01_00_01.c
  group Debug
    ../../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group U8g2
    ../../../../../Platform/Library/U8g2/csrc/: u8g2_arc.c u8g2_bitmap.c u8g2_buffer.c u8g2_box.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_intersection.c u8g2_kerning.c u8g2_ll_hvline.c u8g2_line.c u8g2_polygon.c u8g2_setup.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1309.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_setup.c u8x8_u16toa.c
  group FreeRTOS
    ../../../../../Platform/OS/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../Platform/OS/FreeRTOS/portable/MemMang/: heap_1.c
    ../../../../../Platform/OS/FreeRTOS/portable/RVDS/ARM_CM0/: port.c
target A31C14x_AirClock_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: airclock
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: as above
  link misc: --diag_suppress L6314W
