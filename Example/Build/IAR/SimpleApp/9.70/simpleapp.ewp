# IAR project simpleapp.ewp, settings and files
configuration A31C11x (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31C11x; EXTRN_ABOV_SIMPLEAPP_CONFIG
  ICCARM.CCIncludePath2: ..\..\..\..\..\ProductConfig\Config; ..\..\..\..\..\Platform\HAL\Include; ..\..\..\..\..\Platform\HAL\HPL\Include; ..\..\..\..\..\Platform\Library\ABOV\Debug\Include; ..\..\..\..\..\Framework\CMSIS\Core\Include; ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simpleapp.srec
  ILINK.IlinkOutputFile: simpleapp.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31c11x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ADC
    ../../../../Source/SimpleApp/ADC/: adc_app.c adc_burst.c adc_comparison.c adc_multiple.c adc_sequential.c adc_single.c
  group Config
    ../../../../../ProductConfig/Config/: abov_config.h abov_simpleapp_config.h
  group CRC
    ../../../../Source/SimpleApp/CRC/: crc_16_ccitt.c crc_16_usb.c crc_32.c crc_8_ccitt.c crc_app.c
  group Debug
    ../../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group FMC
    ../../../../Source/SimpleApp/FMC/: fmc_app.c fmc_cfmc.c
  group HAL
    ../../../../../Platform/HAL/ADC/: hal_adc.c
    ../../../../../Platform/HAL/AES/: hal_aes.c
    ../../../../../Platform/HAL/CFMC/: hal_cfmc.c
    ../../../../../Platform/HAL/CMP/: hal_cmp.c
    ../../../../../Platform/HAL/CRC/: hal_crc.c
    ../../../../../Platform/HAL/DAC/: hal_dac.c
    ../../../../../Platform/HAL/EBI/: hal_ebi.c
    ../../../../../Platform/HAL/FMC/: hal_fmc.c
    ../../../../../Platform/HAL/FRT/: hal_frt.c
    ../../../../../Platform/HAL/HSICMU/: hal_hsicmu.c
    ../../../../../Platform/HAL/I2C/: hal_i2c.c
    ../../../../../Platform/HAL/LCD/: hal_lcd.c
    ../../../../../Platform/HAL/LED/: hal_led.c
    ../../../../../Platform/HAL/LPUART/: hal_lpuart.c
    ../../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../../Platform/HAL/RTC/: hal_rtc.c
    ../../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c hal_scu_lvd.c hal_scu_pwr.c
    ../../../../../Platform/HAL/SPI/: hal_spi.c
    ../../../../../Platform/HAL/TempSens/: hal_tempsens.c
    ../../../../../Platform/HAL/Timer1/: hal_timer1.c
    ../../../../../Platform/HAL/Timer2/: hal_timer2.c
    ../../../../../Platform/HAL/Timer3/: hal_timer3.c
    ../../../../../Platform/HAL/Timer4/: hal_timer4.c
    ../../../../../Platform/HAL/Timer4E/: hal_timer4e.c
    ../../../../../Platform/HAL/Timer5/: hal_timer5.c
    ../../../../../Platform/HAL/Timer6/: hal_timer6.c
    ../../../../../Platform/HAL/TRNG/: hal_trng.c
    ../../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../../Platform/HAL/USART/: hal_usart.c
    ../../../../../Platform/HAL/WDT/: hal_wdt.c
    ../../../../../Platform/HAL/WT/: hal_wt.c
    ../../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
  group I2C
    ../../../../Source/SimpleApp/I2C/: i2c_app.c i2c_rx.c i2c_tx.c
  group Main
    ../../../../Source/SimpleApp/: main.c
  group PCU
    ../../../../Source/SimpleApp/PCU/: pcu_app.c pcu_gpio_isr.c
  group SCU
    ../../../../Source/SimpleApp/SCU/: scu_app.c scu_clkout.c scu_lvd_indicator.c scu_lvd_reset.c scu_pwr_deepsleep.c
  group Startup
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a31xxxx.c
  group System
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: system_a31xxxx.c
  group TIMER1
    ../../../../Source/SimpleApp/TIMER1/: timer1_app.c timer1_capture.c timer1_oneshot.c timer1_periodic.c timer1_pwm.c
  group UART
    ../../../../Source/SimpleApp/UART/: uart_app.c uart_rx.c uart_tx.c
  group USART
    ../../../../Source/SimpleApp/USART/: usart_app.c usart_spi_rx.c usart_spi_tx.c usart_uart_rx.c usart_uart_tx.c usart_usrt_rx.c usart_usrt_tx.c
  group WDT
    ../../../../Source/SimpleApp/WDT/: wdt_app.c wdt_reset.c wdt_underflow.c
