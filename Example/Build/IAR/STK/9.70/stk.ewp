# IAR project stk.ewp, settings and files
configuration A31G11x (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G11x; EXTRN_ABOV_EXAMPLE_CONFIG
  ICCARM.CCIncludePath2: ..\..\..\..\..\ProductConfig\Config; ..\..\..\..\..\Platform\HAL\Include; ..\..\..\..\..\Platform\HAL\HPL\Include; ..\..\..\..\..\Platform\Library\ABOV\Debug\Include; ..\..\..\..\..\Framework\CMSIS\Core\Include; ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: stk.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g11x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration A31G12x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G12x; EXTRN_ABOV_EXAMPLE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g12x.icf
configuration A31G21x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G21x; EXTRN_ABOV_EXAMPLE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31xxxx.icf
configuration A31T21x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31T21x; EXTRN_ABOV_EXAMPLE_CONFIG
  OBJCOPY.OOCOutputFile: stk.srec
  ILINK.IlinkIcfFile: as above
configuration A31G22x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G22x; EXTRN_ABOV_EXAMPLE_CONFIG
  ILINK.IlinkIcfFile: as above
configuration A31G31x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G31x; EXTRN_ABOV_EXAMPLE_CONFIG
  ILINK.IlinkIcfFile: as above
configuration A31G32x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G32x; EXTRN_ABOV_EXAMPLE_CONFIG
  ILINK.IlinkIcfFile: as above
configuration A31L21x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31L21x; EXTRN_ABOV_EXAMPLE_CONFIG
  OBJCOPY.OOCOutputFile: stk.srec
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31l21x.icf
configuration A31L12x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31L12x; EXTRN_ABOV_EXAMPLE_CONFIG
  OBJCOPY.OOCOutputFile: stk.srec
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31l12x.icf
configuration A31L22x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31L22x; EXTRN_ABOV_EXAMPLE_CONFIG
  OBJCOPY.OOCOutputFile: stk.srec
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31l22x.icf
configuration A31C14x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31C14x; EXTRN_ABOV_EXAMPLE_CONFIG
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: stk.srec
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31c14x.icf
configuration A31G33x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G33x; EXTRN_ABOV_EXAMPLE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g33x.icf
configuration A31G34x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G34x; EXTRN_ABOV_EXAMPLE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g34x.icf
configuration A31S13x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31S13x; EXTRN_ABOV_EXAMPLE_CONFIG
  OBJCOPY.OOCOutputFile: stk.srec
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31s13x.icf
configuration A31C12x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31C12x; EXTRN_ABOV_EXAMPLE_CONFIG
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: stk.srec
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31c12x.icf
configuration A31C11x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31C11x; EXTRN_ABOV_EXAMPLE_CONFIG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: stk.srec
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31c11x.icf
  group Config
    ../../../../../ProductConfig/Config/: abov_config.h abov_example_config.h
  group Debug
    ../../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group HAL
    ../../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c
    ../../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../../Platform/HAL/USART/: hal_usart.c
    ../../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
  group Main
    ../../../../Source/GpioLedBlinking/: gpio_led_blinking.c
  group Startup
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a31xxxx.c
  group System
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: system_a31xxxx.c
