# IAR project bare.ewp, settings and files
configuration A31G11x (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G11x; EXTRN_ABOV_EXAMPLE_CONFIG; EXTRN_SINGLE_ADC
  ICCARM.CCIncludePath2: ..\..\..\..\..\ProductConfig\Config; ..\..\..\..\..\Platform\HAL\Include; ..\..\..\..\..\Platform\HAL\HPL\Include; ..\..\..\..\..\Example\Source\Bare\Peripheral\Include; ..\..\..\..\..\Platform\Library\ABOV\Debug\Include; ..\..\..\..\..\Framework\CMSIS\Core\Include; ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bare.srec
  ILINK.IlinkOutputFile: bare.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g11x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration A31G12x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G12x; EXTRN_ABOV_EXAMPLE_CONFIG; EXTRN_SINGLE_ADC
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g12x.icf
configuration A31G21x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G21x; EXTRN_ABOV_EXAMPLE_CONFIG; EXTRN_SINGLE_ADC; EXTRN_EX_LED_DEBUG_OTHER
  ICCARM.IExtraOptions: --diag_suppress Ta023
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g21x.icf
configuration A31T21x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31T21x; EXTRN_ABOV_EXAMPLE_CONFIG
  ICCARM.IExtraOptions: --diag_suppress Ta023
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31xxxx.icf
configuration A31G22x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G22x; EXTRN_ABOV_EXAMPLE_CONFIG
  ICCARM.IExtraOptions: --diag_suppress Ta021
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: as above
configuration A31G31x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G31x; EXTRN_ABOV_EXAMPLE_CONFIG; EXTRN_EX_LED_DEBUG_OTHER
  ICCARM.IExtraOptions: --diag_suppress Ta023
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: as above
configuration A31G32x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G32x; EXTRN_ABOV_EXAMPLE_CONFIG
  ICCARM.IExtraOptions: --diag_suppress Ta023
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: as above
configuration A31L21x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31L21x; EXTRN_ABOV_EXAMPLE_CONFIG; EXTRN_SINGLE_ADC; EXTRN_HAS_DEEP_SLEEP_SUB_MODE
  ICCARM.IExtraOptions: --diag_suppress Ta021 --diag_suppress Ta023
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31l21x.icf
configuration A31L12x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31L12x; EXTRN_ABOV_EXAMPLE_CONFIG; EXTRN_SINGLE_ADC; EXTRN_HAS_DEEP_SLEEP_SUB_MODE
  ICCARM.IExtraOptions: --diag_suppress Ta021 --diag_suppress Ta023
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31l12x.icf
configuration A31L22x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31L22x; EXTRN_ABOV_EXAMPLE_CONFIG; EXTRN_SINGLE_ADC; EXTRN_HAS_DEEP_SLEEP_SUB_MODE
  ICCARM.IExtraOptions: --diag_suppress Ta021 --diag_suppress Ta023
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31l22x.icf
configuration A31C14x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31C14x; EXTRN_ABOV_EXAMPLE_CONFIG; EXTRN_SINGLE_ADC
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31c14x.icf
configuration A31G33x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G33x; EXTRN_ABOV_EXAMPLE_CONFIG; EXTRN_SINGLE_ADC
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g33x.icf
configuration A31G34x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G34x; EXTRN_ABOV_EXAMPLE_CONFIG; EXTRN_SINGLE_ADC
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g34x.icf
configuration A31S13x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31S13x; EXTRN_ABOV_EXAMPLE_CONFIG; EXTRN_SINGLE_ADC
  ICCARM.IExtraOptions: --diag_suppress Ta021 --diag_suppress Ta023
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31s13x.icf
configuration A31C12x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31C12x; EXTRN_ABOV_EXAMPLE_CONFIG; EXTRN_SINGLE_ADC
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31c12x.icf
  group Config
    ../../../../../ProductConfig/Config/: abov_config.h abov_example_config.h
  group Debug
    ../../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group Example
    ../../../../Source/Bare/Peripheral/ADC/: adc.c
    ../../../../Source/Bare/Peripheral/AES/: aes.c
    ../../../../Source/Bare/Peripheral/CMP/: cmp.c
    ../../../../Source/Bare/Peripheral/COA/: coa.c
    ../../../../Source/Bare/Peripheral/Flash/: code_flash.c flash.c
    ../../../../Source/Bare/Peripheral/CRC/: crc.c
    ../../../../Source/Bare/Peripheral/DAC/: dac.c
    ../../../../Source/Bare/Peripheral/EBI/: ebi.c
    ../../../../Source/Bare/Peripheral/FRT/: frt.c
    ../../../../Source/Bare/Peripheral/I2C/: i2c.c
    ../../../../Source/Bare/Peripheral/LCD/: lcd.c
    ../../../../Source/Bare/Peripheral/LED/: led.c
    ../../../../Source/Bare/Peripheral/LPUART/: lpuart.c
    ../../../../Source/Bare/Peripheral/PCU/: pcu.c
    ../../../../Source/Bare/Peripheral/RTC/: rtc.c
    ../../../../Source/Bare/Peripheral/SCU/: scu.c scu_clk.c scu_lvd.c scu_pwr.c
    ../../../../Source/Bare/Peripheral/SPI/: spi.c
    ../../../../Source/Bare/Peripheral/TempSens/: tempsens.c
    ../../../../Source/Bare/Peripheral/Timer1/: timer1.c
    ../../../../Source/Bare/Peripheral/Timer2/: timer2.c
    ../../../../Source/Bare/Peripheral/Timer3/: timer3.c
    ../../../../Source/Bare/Peripheral/Timer4/: timer4.c
    ../../../../Source/Bare/Peripheral/Timer4E/: timer4e.c
    ../../../../Source/Bare/Peripheral/Timer5/: timer5.c
    ../../../../Source/Bare/Peripheral/Timer6/: timer6.c
    ../../../../Source/Bare/Peripheral/TRNG/: trng.c
    ../../../../Source/Bare/Peripheral/UART/: uart.c
    ../../../../Source/Bare/Peripheral/USART/: usart.c
    ../../../../Source/Bare/Peripheral/WDT/: wdt.c
    ../../../../Source/Bare/Peripheral/WT/: wt.c
  group HAL
    ../../../../../Platform/HAL/ADC/: hal_adc.c
    ../../../../../Platform/HAL/AES/: hal_aes.c
    ../../../../../Platform/HAL/CFMC/: hal_cfmc.c
    ../../../../../Platform/HAL/CMP/: hal_cmp.c
    ../../../../../Platform/HAL/CRC/: hal_crc.c
    ../../../../../Platform/HAL/DAC/: hal_dac.c
    ../../../../../Platform/HAL/EBI/: hal_ebi.c
    ../../../../../Platform/HAL/FMC/: hal_fmc.c
    ../../../../../Platform/HAL/FRT/: hal_frt.c
    ../../../../../Platform/HAL/I2C/: hal_i2c.c
    ../../../../../Platform/HAL/LCD/: hal_lcd.c
    ../../../../../Platform/HAL/LED/: hal_led.c
    ../../../../../Platform/HAL/LPUART/: hal_lpuart.c
    ../../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../../Platform/HAL/RTC/: hal_rtc.c
    ../../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c hal_scu_lvd.c hal_scu_pwr.c
    ../../../../../Platform/HAL/SPI/: hal_spi.c
    ../../../../../Platform/HAL/TempSens/: hal_tempsens.c
    ../../../../../Platform/HAL/Timer1/: hal_timer1.c
    ../../../../../Platform/HAL/Timer2/: hal_timer2.c
    ../../../../../Platform/HAL/Timer3/: hal_timer3.c
    ../../../../../Platform/HAL/Timer4/: hal_timer4.c
    ../../../../../Platform/HAL/Timer4E/: hal_timer4e.c
    ../../../../../Platform/HAL/Timer5/: hal_timer5.c
    ../../../../../Platform/HAL/Timer6/: hal_timer6.c
    ../../../../../Platform/HAL/TRNG/: hal_trng.c
    ../../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../../Platform/HAL/USART/: hal_usart.c
    ../../../../../Platform/HAL/WDT/: hal_wdt.c
    ../../../../../Platform/HAL/WT/: hal_wt.c
    ../../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
  group Main
    ../../../../Source/Bare/Peripheral/Main/: ex_common.c ex_peripheral.c
  group PrivateHAL
    ../../../../../Platform/HAL/CFMC/Fx/F1x/: hal_cfmc_f_01_00_00.c hal_cfmc_f_01_00_01.c
  group Startup
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a31xxxx.c
  group System
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: system_a31xxxx.c
