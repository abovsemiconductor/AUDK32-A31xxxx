# IAR project tmpl_userapp.ewp, settings and files
configuration A31G11x (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G11x; EXTRN_ABOV_MODULE_CONFIG
  ICCARM.CCIncludePath2: ..\..\..\..\..\ProductConfig\Config; ..\..\..\..\..\Platform\HAL\Include; ..\..\..\..\..\Platform\HAL\HPL\Include; ..\..\..\..\..\Example\Source\Bare\Peripheral\Include; ..\..\..\..\..\Platform\Library\ABOV\Debug\Include; ..\..\..\..\..\Framework\CMSIS\Core\Include; ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tmpl_userapp.srec
  ILINK.IlinkOutputFile: tmpl_userapp.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g11x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration A31G12x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G12x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g12x.icf
configuration A31G21x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G21x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g21x.icf
configuration A31T21x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31T21x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31xxxx.icf
configuration A31G22x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G22x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: as above
configuration A31G31x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G31x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: as above
configuration A31G32x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G32x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: as above
configuration A31C14x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31C14x; EXTRN_ABOV_MODULE_CONFIG
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31c14x.icf
configuration A31L21x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31L21x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31l21x.icf
configuration A31L22x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31L22x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31l22x.icf
configuration A31L12x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31L12x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31l12x.icf
configuration A31G33x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G33x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g33x.icf
configuration A31G34x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31G34x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31g34x.icf
configuration A31S13x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31S13x; EXTRN_ABOV_MODULE_CONFIG
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31s13x.icf
configuration A31C12x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31C12x; EXTRN_ABOV_MODULE_CONFIG
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31c12x.icf
configuration A31C11x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EXTRN_SUBFAMILY_A31C11x; EXTRN_ABOV_MODULE_CONFIG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: ..\..\..\..\..\Framework\CMSIS\Device\ABOV\Source\IAR\a31c11x.icf
  group Config
    ../../../../../ProductConfig/Config/: abov_config.h abov_module_config.h
  group Debug
    ../../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group HAL
    ../../../../../Platform/HAL/ADC/: hal_adc.c
    ../../../../../Platform/HAL/AES/: hal_aes.c
    ../../../../../Platform/HAL/CFMC/: hal_cfmc.c
    ../../../../../Platform/HAL/CMP/: hal_cmp.c
    ../../../../../Platform/HAL/CRC/: hal_crc.c
    ../../../../../Platform/HAL/DAC/: hal_dac.c
    ../../../../../Platform/HAL/EBI/: hal_ebi.c
    ../../../../../Platform/HAL/FMC/: hal_fmc.c
    ../../../../../Platform/HAL/FRT/: hal_frt.c
    ../../../../../Platform/HAL/I2C/: hal_i2c.c
    ../../../../../Platform/HAL/LCD/: hal_lcd.c
    ../../../../../Platform/HAL/LED/: hal_led.c
    ../../../../../Platform/HAL/LPUART/: hal_lpuart.c
    ../../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../../Platform/HAL/RTC/: hal_rtc.c
    ../../../../../Platform/HAL/SCU/: hal_scu.c hal_scu_clk.c hal_scu_lvd.c hal_scu_pwr.c
    ../../../../../Platform/HAL/SPI/: hal_spi.c
    ../../../../../Platform/HAL/TempSens/: hal_tempsens.c
    ../../../../../Platform/HAL/Timer1/: hal_timer1.c
    ../../../../../Platform/HAL/Timer2/: hal_timer2.c
    ../../../../../Platform/HAL/Timer3/: hal_timer3.c
    ../../../../../Platform/HAL/Timer4/: hal_timer4.c
    ../../../../../Platform/HAL/Timer4E/: hal_timer4e.c
    ../../../../../Platform/HAL/Timer5/: hal_timer5.c
    ../../../../../Platform/HAL/Timer6/: hal_timer6.c
    ../../../../../Platform/HAL/TRNG/: hal_trng.c
    ../../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../../Platform/HAL/USART/: hal_usart.c
    ../../../../../Platform/HAL/WDT/: hal_wdt.c
    ../../../../../Platform/HAL/WT/: hal_wt.c
    ../../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
  group Main
    ../../../../Source/TmplUserApp/: main.c prv_scu_clk.c prv_user_code.c
  group PrivateHAL
    ../../../../../Platform/HAL/CFMC/Fx/F1x/: hal_cfmc_f_01_00_00.c hal_cfmc_f_01_00_01.c
  group Startup
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a31xxxx.c
  group System
    ../../../../../Framework/CMSIS/Device/ABOV/Source/: system_a31xxxx.c
